FILES_${PN} = "${bindir}/xinit ${libdir}/X11/*"
