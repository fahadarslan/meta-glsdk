
SRC_URI = "ftp://swubn01.india.ti.com/AragoRepo/glsdk/vim_7.4.27.tar.gz;protocol=ftp"

SRC_URI[md5sum] = "c87d383e1357274614d3de8d0b859eee"
SRC_URI[sha256sum] = "5860c7018dc066bcb8c6be158413aadc82dd88f2ec6c62f43b028f77ab865d82"

