SRC_URI = "ftp://swubn01.india.ti.com/AragoRepo/glsdk/dspdce/dspdce-dra7xx-evm-1.00.00.02.tar.gz;protocol=ftp"

SRC_URI[md5sum] = "533021004a46908cf9d5f3cdd5c82ea7"
SRC_URI[sha256sum] = "a2f6232e4387c593e83194948fe24a83a1a91fe799b9a302dcf0b757b801ffd7"


