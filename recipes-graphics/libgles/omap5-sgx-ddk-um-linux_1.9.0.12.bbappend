SRC_URI = "git://git.ti.com/graphics/omap5-sgx-ddk-um-linux.git;protocol=git"

SRCREV = "0af11b676900de5a3e5550728fe18acd88c29848"

PR = "r10"

