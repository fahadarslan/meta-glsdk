SRC_URI = "git://git.omapzoom.org/platform/external/bltsville.git;protocol=git"
