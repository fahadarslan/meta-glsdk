DEPENDS = "gstreamer1.0 libdrm ti-ipc"

FILESEXTRAPATHS_prepend := "${THISDIR}:"

SRCREV = "ac71e62ec2bd4c94cd73f24fcf0fc8f4f2876dc8"

SRC_URI = "git://git.ti.com/glsdk/example-applications.git;protocol=git"

PR = "r8"
