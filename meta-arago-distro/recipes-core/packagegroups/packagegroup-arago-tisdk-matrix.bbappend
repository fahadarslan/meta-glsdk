PR = "r29"

MATRIX_COMMON_APPS = "              \
    matrix-gui-armbenchmarks-demos  \
    matrix-gui-crypto-demos         \
    matrix-gui-oprofile-demos       \
"

RDEPENDS_${PN} = "        \
    ${MATRIX_COMMON_APPS} \
"
